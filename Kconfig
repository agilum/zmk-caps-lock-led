## Kconfig
```kconfig
config CAPS_LOCK_LED
    bool "Enable caps lock LED indicator module"
    default y
```
